; Anonymous `circuit.Package`
; Generated by `vlsirtools.XyceNetlister`
;

.SUBCKT lut_tap_template
; No ports
; No parameters

.ENDS

.SUBCKT lut_dfxtp_0_0_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_1_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_2_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_3_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_4_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_5_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_6_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_0_7_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_0_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT buf_0_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

.SUBCKT lut_dfxtp_1_1_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_2_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_3_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_4_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_5_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_6_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT lut_dfxtp_1_7_template
+ D CLK CLKI Q VPWR VGND VPB VNB
; No parameters

xnfet_0
+ a D VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_1
+ b CLK a VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_2
+ e c VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_3
+ b CLK e VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_4
+ c b VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={640m}

xnfet_5
+ f CLK c VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_6
+ i Q_N VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={420m}

xnfet_7
+ f CLKI i VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={360m}

xnfet_8
+ Q_N f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xnfet_9
+ Q f VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={650m}

xpfet_0
+ a D VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_1
+ b CLKI a VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_2
+ d c VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_3
+ b CLKI d VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_4
+ c b VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={750m}

xpfet_5
+ f CLKI c VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_6
+ h Q_N VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_7
+ f CLK h VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={420m}

xpfet_8
+ Q_N f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

xpfet_9
+ Q f VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={1000m}

.ENDS

.SUBCKT sky130_mux
+ S0 S0_B S1 S1_B S2 S2_B input_0 input_1 input_2 input_3 input_4 input_5 input_6 input_7 Z VPB VNB
; No parameters

xupper_left__fet0
+ upper_left__A0 S0_B input_2 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet1
+ upper_left__A1 S0_B input_0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet2
+ input_3 S0 upper_left__A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet3
+ input_1 S0 upper_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet4
+ A0 S1_B upper_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet5
+ upper_left__A0 S1 A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet0
+ lower_left__A0 S0_B input_6 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet1
+ lower_left__A1 S0_B input_4 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet2
+ input_7 S0 lower_left__A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet3
+ input_5 S0 lower_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet4
+ A1 S1_B lower_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet5
+ lower_left__A0 S1 A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_right__fet0
+ upper_right__A0 S0 input_2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet1
+ upper_right__A1 S0 input_0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet2
+ input_3 S0_B upper_right__A0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet3
+ input_1 S0_B upper_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet4
+ A2 S1 upper_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet5
+ upper_right__A0 S1_B A2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet0
+ lower_right__A0 S0 input_6 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet1
+ lower_right__A1 S0 input_4 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet2
+ input_7 S0_B lower_right__A0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet3
+ input_5 S0_B lower_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet4
+ A3 S1 lower_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet5
+ lower_right__A0 S1_B A3 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xoutput_mux2__nfet0
+ Z S2_B A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xoutput_mux2__nfet1
+ A1 S2 Z VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xoutput_mux2__pfet0
+ Z S2 A2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xoutput_mux2__pfet1
+ A3 S2_B Z VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

.ENDS

.SUBCKT buf_3_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

.SUBCKT buf_1_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

.SUBCKT hd_mux2_1_0_template
+ S A0 A1 X VPWR VGND VPB VNB
; No parameters

xn0
+ S_B S VGND VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xn1
+ I1 S_B VGND VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xn2
+ X_B A1 I1 VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xn3
+ I3 S_B VGND VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xn4
+ X_B A0 I3 VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xn5
+ X X_B VGND VNB
+ sky130_fd_pr__nfet_01v8
+ ; No parameters

xp0
+ S_B S VPWR VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

xp1
+ I0 S VPWR VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

xp2
+ X_B A0 I0 VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

xp3
+ I2 S_B VPWR VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

xp4
+ X_B A1 I2 VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

xp5
+ X X_B VPWR VPB
+ sky130_fd_pr__pfet_01v8
+ ; No parameters

.ENDS

.SUBCKT clk_buf_0_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

.SUBCKT alt_sky130_mux
+ S0 S0_B S1 S1_B S2 S2_B input_0 input_1 input_2 input_3 input_4 input_5 input_6 input_7 Z VPB VNB
; No parameters

xupper_left__fet0
+ upper_left__A0 S0_B input_2 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet1
+ upper_left__A1 S0_B input_0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet2
+ input_3 S0 upper_left__A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet3
+ input_1 S0 upper_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet4
+ A0 S1_B upper_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_left__fet5
+ upper_left__A0 S1 A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet0
+ lower_left__A0 S0_B input_6 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet1
+ lower_left__A1 S0_B input_4 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet2
+ input_7 S0 lower_left__A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet3
+ input_5 S0 lower_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet4
+ A1 S1_B lower_left__A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xlower_left__fet5
+ lower_left__A0 S1 A1 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xupper_right__fet0
+ upper_right__A0 S0 input_2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet1
+ upper_right__A1 S0 input_0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet2
+ input_3 S0_B upper_right__A0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet3
+ input_1 S0_B upper_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet4
+ A2 S1 upper_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xupper_right__fet5
+ upper_right__A0 S1_B A2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet0
+ lower_right__A0 S0 input_6 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet1
+ lower_right__A1 S0 input_4 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet2
+ input_7 S0_B lower_right__A0 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet3
+ input_5 S0_B lower_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet4
+ A3 S1 lower_right__A1 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xlower_right__fet5
+ lower_right__A0 S1_B A3 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xoutput_mux2__nfet0
+ Z S2_B A0 VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xoutput_mux2__nfet1
+ A1 S2 Z VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: w={480m} l={170m}

xoutput_mux2__pfet0
+ Z S2 A2 VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

xoutput_mux2__pfet1
+ A3 S2_B Z VPB
+ sky130_fd_pr__pfet_01v8
+ PARAMS: w={640m} l={170m}

.ENDS

.SUBCKT clk_buf_1_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

.SUBCKT buf_2_template
+ X P A VPWR VGND VPB VNB
; No parameters

xnfet_0
+ P A VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_0
+ P A VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

xnfet_1
+ X P VGND VNB
+ sky130_fd_pr__nfet_01v8
+ PARAMS: l={150m} w={520m}

xpfet_1
+ X P VPWR VPB
+ sky130_fd_pr__pfet_01v8_hvt
+ PARAMS: l={150m} w={790m}

.ENDS

*.SUBCKT lut
*+ S0 S1 S2 S3 Z CONFIG_IN CONFIG_OUT CLK VPWR_0 VPWR_1 VGND_0 VGND_1
*; No parameters
*
*xlut_dfxtp_0_0
*+ CONFIG_IN clk_0 clk_i_0 lut_dfxtp_0_0.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_0_template
*+ ; No parameters
*
*xlut_dfxtp_0_1
*+ lut_dfxtp_0_0.Q clk_0 clk_i_0 lut_dfxtp_0_1.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_1_template
*+ ; No parameters
*
*xlut_dfxtp_0_2
*+ lut_dfxtp_0_1.Q clk_0 clk_i_0 lut_dfxtp_0_2.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_2_template
*+ ; No parameters
*
*xlut_dfxtp_0_3
*+ lut_dfxtp_0_2.Q clk_0 clk_i_0 lut_dfxtp_0_3.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_3_template
*+ ; No parameters
*
*xlut_dfxtp_0_4
*+ lut_dfxtp_0_3.Q clk_0 clk_i_0 lut_dfxtp_0_4.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_4_template
*+ ; No parameters
*
*xlut_dfxtp_0_5
*+ lut_dfxtp_0_4.Q clk_0 clk_i_0 lut_dfxtp_0_5.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_5_template
*+ ; No parameters
*
*xlut_dfxtp_0_6
*+ lut_dfxtp_0_5.Q clk_0 clk_i_0 lut_dfxtp_0_6.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_6_template
*+ ; No parameters
*
*xlut_dfxtp_0_7
*+ lut_dfxtp_0_6.Q clk_0 clk_i_0 lut_dfxtp_0_7.Q vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ lut_dfxtp_0_7_template
*+ ; No parameters
*
*xlut_dfxtp_1_0
*+ lut_dfxtp_0_7.Q clk_1 clk_i_1 lut_dfxtp_1_0.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_0_template
*+ ; No parameters
*
*xlut_dfxtp_1_1
*+ lut_dfxtp_1_0.Q clk_1 clk_i_1 lut_dfxtp_1_1.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_1_template
*+ ; No parameters
*
*xlut_dfxtp_1_2
*+ lut_dfxtp_1_1.Q clk_1 clk_i_1 lut_dfxtp_1_2.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_2_template
*+ ; No parameters
*
*xlut_dfxtp_1_3
*+ lut_dfxtp_1_2.Q clk_1 clk_i_1 lut_dfxtp_1_3.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_3_template
*+ ; No parameters
*
*xlut_dfxtp_1_4
*+ lut_dfxtp_1_3.Q clk_1 clk_i_1 lut_dfxtp_1_4.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_4_template
*+ ; No parameters
*
*xlut_dfxtp_1_5
*+ lut_dfxtp_1_4.Q clk_1 clk_i_1 lut_dfxtp_1_5.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_5_template
*+ ; No parameters
*
*xlut_dfxtp_1_6
*+ lut_dfxtp_1_5.Q clk_1 clk_i_1 lut_dfxtp_1_6.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_6_template
*+ ; No parameters
*
*xlut_dfxtp_1_7
*+ lut_dfxtp_1_6.Q clk_1 clk_i_1 lut_dfxtp_1_7.Q vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ lut_dfxtp_1_7_template
*+ ; No parameters
*
*xmux_0
*+ n_1 n_0 n_3 n_2 n_5 n_4 lut_dfxtp_0_1.Q lut_dfxtp_0_0.Q lut_dfxtp_0_2.Q lut_dfxtp_0_3.Q lut_dfxtp_1_5.Q lut_dfxtp_1_4.Q lut_dfxtp_1_6.Q lut_dfxtp_1_7.Q n_7 VPWR VGND
*+ sky130_mux
*+ ; No parameters
*
*xmux_1
*+ n_1 n_0 n_3 n_2 n_5 n_4 lut_dfxtp_1_2.Q lut_dfxtp_1_3.Q lut_dfxtp_1_1.Q lut_dfxtp_1_0.Q lut_dfxtp_0_6.Q lut_dfxtp_0_7.Q lut_dfxtp_0_5.Q lut_dfxtp_0_4.Q n_8 VPWR VGND
*+ alt_sky130_mux
*+ ; No parameters
*
*xbuf_0
*+ n_1 n_0 S0 vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ buf_0_template
*+ ; No parameters
*
*xbuf_1
*+ n_3 n_2 S1 vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ buf_1_template
*+ ; No parameters
*
*xbuf_2
*+ n_5 n_4 S2 vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ buf_2_template
*+ ; No parameters
*
*xclk_buf_0
*+ clk_0 clk_i_0 CLK vpwr_0 vgnd_0 vpwr_0 vgnd_0
*+ clk_buf_0_template
*+ ; No parameters
*
*xbuf_3
*+ n_6 n_9 S3 vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ buf_3_template
*+ ; No parameters
*
*xclk_buf_1
*+ clk_1 clk_i_1 CLK vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ clk_buf_1_template
*+ ; No parameters
*
*xhd_mux2_1_0
*+ n_6 n_7 n_8 Z vpwr_1 vgnd_1 vpwr_1 vgnd_1
*+ hd_mux2_1_0_template
*+ ; No parameters
*
*.ENDS
